# Keil uVision project k20dx128_prog_app.uvproj, settings and files
target k20dx128_prog_app (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx128_prog_app +hex
  AfterMake: %KARM\ARMCC\bin\fromelf --bin --output=".\k20dx128_prog_app.bin" "#L"
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_prog_app.S19" "#L"
  c flags: Optim=2
  c define: __RTX, TARGET_MK20DX, MKP128_50MHZ, INTERFACE_POWER_EN, OFFSET_VTABLE_20K
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\hal\TARGET_Freescale\TARGET_MK20DX\C90TFS\drvsrc\include;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\target\hal\DBG_Freescale\common;..\..\target\hal\DBG_Freescale\DBG_KL26Z
  asm define: MBED_BOOTLOADER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5_mbed_bootloader.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/TOOLCHAIN_ARM_STD/: startup_MK20D5.s
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/: system_MK20D5.c
  group Common
    ../../Common/src/: flash_svc.c main.c RTX_Config.c SVC_Table.s usb_config.c usbd_user_msc.c version.c Debug_cm.c swd_host.c DAP.c JTAG_DP.c SW_DP.c semihost.c
    ../../interface/hal/TARGET_Freescale/TARGET_MK20DX/: spi_flash.c
  group HAL
    ../../hal/TARGET_Freescale/TARGET_MK20DX/: flash.c gpio.c read_uid.c vector_table.c usbd_MK20D5.c
    ../../hal/TARGET_Freescale/TARGET_MK20DX/C90TFS/drvsrc/source/: FlashEraseAllBlock.c FlashEraseSector.c FlashInit.c FlashProgramLongword.c FlashCommandSequence.c
    ../../target/hal/DBG_Freescale/common/: target_reset_Lseries.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
